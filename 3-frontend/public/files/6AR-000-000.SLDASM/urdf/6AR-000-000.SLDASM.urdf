Commit message: Web UI Refractor

File: 3-frontend/public/files/6AR-000-000.SLDASM/urdf/6AR-000-000.SLDASM.urdf (robot description, URDF)
Before this commit: robot 6AR-000-000.SLDASM, 7 links, 6 joints
Joints:
- joint J3: axis 0 1 0 -> 0 -1 0
- joint J5: axis 0 0 -1 -> 0 0 1
